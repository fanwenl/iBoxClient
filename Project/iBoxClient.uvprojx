# Keil uVision project iBoxClient.uvprojx, settings and files
target iBoxClient (6070000::V6.7::.\ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: iBoxClient +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o  ./Objects/iBoxClient.bin  ./Objects/iBoxClient.axf
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,HSE_VALUE=12000000
  c include: ..\Application\inc;..\Drivers\BSP\inc;..\Drivers\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Drivers\CMSIS\CM3\CoreSupport;..\Drivers\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ../Application/src/: main.c stm32f10x_it.c
  group BSP
    ../Drivers/BSP/src/: ibox_led.c ibox_adc.c ibox_Ethernet.c ibox_gprs.c ibox_io.c ibox_lora.c ibox_uart.c ibox_wifi.c ibox_sys.c ibox_dac.c ibox_wdog.c
  group CMSIS
    ../Drivers/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Drivers/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../Drivers/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group Library
    ../Drivers/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group map
    ./Listings/: iBoxClient.map
